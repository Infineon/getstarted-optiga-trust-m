# Keil uVision project xmc4800_optiga_example.uvprojx, settings and files
target XMC4800-F100x2048 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4800-F100x2048 Infineon
  pack: Infineon.XMC4000_DFP.2.11.0
  cpu: IRAM(0x20000000,0x3FFC0) IRAM2(0x1FFE8000,0x18000) IROM(0x08000000,0x200000) IROM2(0x0C000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: xmc4800_optiga_example +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress=9529,66
  c include: ..\..\..\optiga\include;..\common\Libraries\XMCLib\inc;..\..\..\externals\mbedtls\include\;..\..\..\examples\optiga\include;..\..\..\externals\alios\security\irot\se\src;..\..\..\examples\integration\alios;..\..\..\externals\alios\security\irot\se\chipset\chip_template;..\..\..\externals\alios\security\irot\se\chipset\chip_template\include
  asm define: STACK_SIZE_VAL=0x0002000,HEAP_SIZE_VAL=0x00002000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x3ffc0
  memory RVCT10: RAM 0x1ffe8000 size 0x18000
  group main
    ../: main_xmc4800_example.c
  group examples
    ../../../examples/optiga/: example_optiga_util_read_data.c example_optiga_util_write_data.c example_optiga_util_update_count.c example_optiga_util_protected_update.c example_optiga_crypt_ecdsa_verify.c example_optiga_crypt_ecdh.c example_optiga_crypt_ecdsa_sign.c example_optiga_crypt_ecc_generate_keypair.c example_optiga_crypt_rsa_generate_keypair.c example_optiga_crypt_rsa_verify.c example_optiga_crypt_rsa_sign.c example_optiga_crypt_rsa_decrypt.c example_optiga_crypt_rsa_encrypt_message.c example_optiga_crypt_rsa_encrypt_session.c example_optiga_crypt_tls_prf_sha256.c example_optiga_crypt_hash.c example_optiga_crypt_random.c example_optiga_crypt_symmetric_encrypt_decrypt_ecb.c example_optiga_crypt_symmetric_encrypt_decrypt.c example_optiga_crypt_hkdf.c example_optiga_crypt_hmac.c example_optiga_crypt_symmetric_generate_key.c example_utilities.c example_optiga_crypt_clear_auto_state.c example_optiga_init_deinit.c
    ../../../examples/: optiga_shell.c
  group usecases
    ../../../examples/optiga/usecases/: example_pair_host_and_optiga_using_pre_shared_secret.c example_optiga_hibernate_restore.c example_read_coprocessor_id.c example_optiga_hmac_verify_with_authorization_reference.c
  group optiga_util
    ../../../optiga/util/: optiga_util.c
  group optiga_crypt
    ../../../optiga/crypt/: optiga_crypt.c
  group optiga_cmd
    ../../../optiga/cmd/: optiga_cmd.c
  group optiga_comms
    ../../../optiga/comms/: optiga_comms_ifx_i2c.c
  group ifx_i2c
    ../../../optiga/comms/ifx_i2c/: ifx_i2c.c ifx_i2c_config.c ifx_i2c_data_link_layer.c ifx_i2c_physical_layer.c ifx_i2c_transport_layer.c ifx_i2c_presentation_layer.c
  group optiga_lib_common
    ../../../optiga/common/: optiga_lib_common.c optiga_lib_logger.c
  group sw_crypto_lib
    ../../../externals/mbedtls/library/: aes.c ccm.c cipher.c cipher_wrap.c md.c md_wrap.c sha256.c platform_util.c
  group pal
    ../../../pal/xmc4800/: pal_gpio.c pal_i2c.c pal_ifx_i2c_config.c pal_os_event.c pal_os_timer.c pal_os_lock.c pal_os_datastore.c pal.c pal_logger.c pal_os_memory.c
    ../../../pal/: pal_crypt_mbedtls.c
software components: CMSIS:CORE 5.1.1, Device:Startup 2.2.0, Device:XMClib:CAN 2.1.18, Device:XMClib:CCU4 2.1.18, Device:XMClib:CCU8 2.1.18, Device:XMClib:DAC 2.1.18, Device:XMClib:DMA 2.1.18, Device:XMClib:DSD 2.1.18, Device:XMClib:EBU 2.1.18, Device:XMClib:ERU 2.1.18, Device:XMClib:ETH_MAC 2.1.18, Device:XMClib:FCE 2.1.18, Device:XMClib:FLASH 2.1.18, Device:XMClib:GPIO 2.1.18, Device:XMClib:HRPWM 2.1.18, Device:XMClib:I2C 2.1.18, Device:XMClib:I2S 2.1.18, Device:XMClib:LEDTS 2.1.18, Device:XMClib:POSIF 2.1.18, Device:XMClib:RTC 2.1.18, Device:XMClib:SCU 2.1.18, Device:XMClib:SDMMC 2.1.18, Device:XMClib:SPI 2.1.18, Device:XMClib:UART 2.1.18, Device:XMClib:USB 2.1.18, Device:XMClib:VADC 2.1.18, Device:XMClib:WDT 2.1.18
